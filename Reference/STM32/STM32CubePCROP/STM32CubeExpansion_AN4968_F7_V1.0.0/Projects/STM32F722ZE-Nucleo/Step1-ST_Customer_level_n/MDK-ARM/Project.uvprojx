# Keil uVision project Project.uvprojx, settings and files
target PCROP-IP-Code-XO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F722ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.2
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: PCROP-IP-Code-XO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F722xx, USE_STM32F7XX_NUCLEO_144, ARM_MATH_CM7, __FPU_PRESENT =1
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F7xx_Nucleo_144
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\PCROP-w-XO.sct
  link misc: --symdefs=fir_filter.txt
  group Drivers/BSP/STM32F722ZE-Nucleo
    ../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c
  group Example/MDK-ARM
    ./: startup_stm32f722xx.s
  group Example/User
    ../Src/: stm32f7xx_it.c main.c arm_fir_data.c math_helper.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group FIR-Filter
    ../Src/: fir_filter.c arm_fir_init_f32.c arm_fir_f32.c
target PCROP-IP-Code (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F722ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.2
  cpu: as above
  output: PCROP-IP-Code
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F722xx, USE_STM32F7XX_NUCLEO_144, ARM_MATH_CM7,  __FPU_PRESENT=1
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\PCROP-wo-XO.sct
  link misc: --symdefs=fir_filter.txt
software components: CMSIS:CORE 5.0.0
