# IAR project Project.ewp, settings and files
configuration PCROP-IP-Code-XO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM32F429I_DISCO; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32F429I-Discovery; ..\Inc; ..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: PCROP.icf
  ILINK.IlinkExtraOptions: --no_literal_pool
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PCROP-IP-Code (ARM, debug)
  as the first configuration, except:
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F429I-Discovery
    ../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group EWARM
    ./: startup_stm32f429xx.s
  group FIR-Filter
    ../Src/: arm_fir_f32.c arm_fir_init_f32.c fir_filter.c
  group User
    ../Src/: arm_fir_data.c main.c math_helper.c stm32f4xx_hal_msp.c stm32f4xx_it.c
