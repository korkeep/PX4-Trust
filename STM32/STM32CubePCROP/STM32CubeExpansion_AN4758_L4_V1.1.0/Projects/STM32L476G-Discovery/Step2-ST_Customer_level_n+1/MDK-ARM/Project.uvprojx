# Keil uVision project Project.uvprojx, settings and files
target PCROP_STEP2 (ARM-ADS)
  device: STM32L476VG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.0.0.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: go_ok
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_DISCO_REVB, ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32L476G-Discovery;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT5: ROM 0x800c000 size 0x14000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\STM32L476G-PCROP-STEP2.sct
  link misc: --diag_suppress=L6329
--symdefs=filtre.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_lptim.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc.c stm32l4xx_hal_hcd.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_usart.c stm32l4xx_hal_can.c stm32l4xx_hal_spi.c stm32l4xx_ll_usb.c stm32l4xx_hal_pwr.c stm32l4xx_hal_lcd.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_nor.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_pcd.c stm32l4xx_ll_fmc.c stm32l4xx_hal_rtc_ex.c
  group User/Main
    ../Src/: stm32l4xx_it.c main.c arm_fir_data.c math_helper.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
    ../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L476G-Discovery
    ../../../../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery.c stm32l476g_discovery_glass_lcd.c
  group User/Fir
    ../Src/: fir_filter.txt
