# Keil uVision project Project.uvprojx, settings and files
target PCROP-IP-Code-XO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.3
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F429I-Discovery;..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT5: ROM 0x80e0000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\PCROP-w-XO.sct
  link misc: --diag_suppress=L6329
--symdefs=fir_filter.txt
  group Doc
    ../: readme.txt
  group MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32F429I-Discovery
    ../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c
  group FIR-Filter
    ../Src/: arm_fir_f32.c arm_fir_init_f32.c fir_filter.c
  group User
    ../Src/: arm_fir_data.c math_helper.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c
target PCROP-IP-Code (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.3
  cpu: as above
  output: STM32F429I-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT5: ROM 0x80e0000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\PCROP-wo-XO.sct
  link misc: --diag_suppress=L6329
