# IAR project Project.ewp, settings and files
configuration PCROP-IP-Code-XO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F722ZE ST STM32F722ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F722xx; USE_STM32F7XX_NUCLEO_144; ARM_MATH_CM7; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ../Inc; ../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../../../../Drivers/STM32F7xx_HAL_Driver/Inc; ../../../../Drivers/BSP/STM32F7xx_Nucleo_144
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f722xx_PCROP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PCROP-IP-Code (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Project.hex
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F722ZE-Nucleo
    ../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_stm32f722xx.s
  group Example/User
    ../Src/: arm_fir_data.c main.c math_helper.c stm32f7xx_it.c
  group FIR-Filter
    ../Src/: arm_fir_f32.c arm_fir_init_f32.c fir_filter.c
